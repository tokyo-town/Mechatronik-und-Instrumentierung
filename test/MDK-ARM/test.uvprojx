# Keil uVision project test.uvprojx, settings and files
target test (6240000::V6.24::ARMCLANG)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: test +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_FULL_LL_DRIVER,HSE_VALUE=25000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=12288000,HSI_VALUE=16000000,LSI_VALUE=32000,VDD_VALUE=3300,PREFETCH_ENABLE=1,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1,STM32F446xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32f446xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f4xx_it.c letters.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_ll_gpio.c stm32f4xx_ll_rcc.c stm32f4xx_ll_utils.c stm32f4xx_ll_exti.c stm32f4xx_ll_usart.c stm32f4xx_ll_tim.c stm32f4xx_ll_pwr.c stm32f4xx_ll_adc.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
software components: CMSIS:CORE 6.1.0
